# IAR project efr32.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: $--partNumber--$ SiliconLaboratories $--partNumber--$
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; PHY_EFR32; $--chipFamily;U--$; $--partNumber--$; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/$--deviceName--$/$--deviceName--$_endpoint_config.h"; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/$--deviceName--$/$--tokenHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/$--deviceName--$/$--deviceName--$.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\util; $--frameworkDirFromProjBs--$\include; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\micro\cortexm3\efm32; $--halDirFromProjBs--$\micro\cortexm3\efm32\config; $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32; $--halDirFromProjBs--$\..\..\CMSIS\Include; $--halDirFromProjBs--$\..\..\Device\SiliconLabs\$--chipFamily--$\Include; $--halDirFromProjBs--$\..\..\emdrv\common\inc; $--halDirFromProjBs--$\..\..\emdrv\config; $--halDirFromProjBs--$\..\..\emdrv\dmadrv\inc; $--halDirFromProjBs--$\..\..\emdrv\gpiointerrupt\inc; $--halDirFromProjBs--$\..\..\emdrv\rtcdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\sleep\inc; $--halDirFromProjBs--$\..\..\emdrv\spidrv\inc; $--halDirFromProjBs--$\..\..\emdrv\tempdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\uartdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\ustimer\inc; $--halDirFromProjBs--$\..\..\emlib\inc; $--halDirFromProjBs--$\..\..\..\hardware\kit\common\bsp\; $--halDirFromProjBs--$\..\..\middleware\glib; $--halDirFromProjBs--$\..\..\middleware\glib\glib; $--halDirFromProjBs--$\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; $--halDirFromProjBs--$\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_EFR32; $--chipFamily;U--$; $--partNumber--$; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/$--deviceName--$/$--deviceName--$_endpoint_config.h"; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/$--deviceName--$/$--tokenHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/$--deviceName--$/$--deviceName--$.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\util; $--frameworkDirFromProjBs--$\include; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\micro\cortexm3\efm32; $--halDirFromProjBs--$\micro\cortexm3\efm32\config; $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32; $--halDirFromProjBs--$\..\..\CMSIS\Include; $--halDirFromProjBs--$\..\..\Device\SiliconLabs\$--chipFamily--$\Include; $--halDirFromProjBs--$\..\..\emdrv\common\inc; $--halDirFromProjBs--$\..\..\emdrv\config; $--halDirFromProjBs--$\..\..\emdrv\dmadrv\inc; $--halDirFromProjBs--$\..\..\emdrv\ecode; $--halDirFromProjBs--$\..\..\emdrv\gpiointerrupt\inc; $--halDirFromProjBs--$\..\..\emdrv\rtcdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\sleep\inc; $--halDirFromProjBs--$\..\..\emdrv\spidrv\inc; $--halDirFromProjBs--$\..\..\emdrv\tempdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\uartdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\ustimer\inc; $--halDirFromProjBs--$\..\..\emlib\inc; $--halDirFromProjBs--$\..\..\middleware\glib; $--halDirFromProjBs--$\..\..\middleware\glib\glib; $--halDirFromProjBs--$\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; $--halDirFromProjBs--$\..\..\radio\rail_lib\chip\efr32\rf\common\cortex
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  postbuild: $--deviceName--$.bat $TARGET_BPATH$ \..\..\..
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: $--bootloader--$=1
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ./: call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    $--halDirFromProjFs--$/micro/cortexm3/efm32/: adc.c assert-crash-handlers.c button.c buzzer.c cstartup-common.c diagnostic.c faults-v7m.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token-def.c token.c
    $--frameworkDirFromProjFs--$/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c time-util.c util.c
    $--frameworkDirFromProjFs--$/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    $--frameworkDirFromProjFs--$/../util/serial/: command-interpreter2.c
    $--halDirFromProjFs--$/micro/generic/: crc.c endian.c mem-util.c random.c
    $--halDirFromProjFs--$/: ember-configuration.c
    $--frameworkDirFromProjFs--$/../util/common/: library.c
    $--frameworkDirFromProjFs--$/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    $--frameworkDirFromProjFs--$/../util/security/: security-address-cache.c
    $--halDirFromProjFs--$/plugin/serial/: serial.c
    $--halDirFromProjFs--$/plugin/serial/cortexm/efm32/: com.c
    _replace_halDirFromProjFs_/micro/cortexm3/efm32/: ext-device.c
    $--frameworkDirFromProjFs--$/../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group emdrv
    $--halDirFromProjBs--$/../../emdrv/dmadrv/src/: dmadrv.c
    $--halDirFromProjBs--$/../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
    $--halDirFromProjBs--$/../../emdrv/rtcdrv/src/: rtcdriver.c
    $--halDirFromProjBs--$/../../emdrv/sleep/src/: sleep.c
    $--halDirFromProjBs--$/../../emdrv/spidrv/src/: spidrv.c
    $--halDirFromProjBs--$/../../emdrv/tempdrv/src/: tempdrv.c
    $--halDirFromProjBs--$/../../emdrv/uartdrv/src/: uartdrv.c
    $--halDirFromProjBs--$/../../emdrv/ustimer/src/: ustimer.c
  group emlib
    $--halDirFromProjBs--$/../../Device/SiliconLabs/$--chipFamily;U--$/Source/: system_$--chipFamily;L--$.c
    $--halDirFromProjBs--$/../../emlib/src/: em_adc.c em_cmu.c em_emu.c em_gpio.c em_int.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
