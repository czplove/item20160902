# IAR project em317.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: $--bootloader--$; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_$--architectureId;U--$; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/$--deviceName--$/$--deviceName--$_endpoint_config.h"; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/$--deviceName--$/$--tokenHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/$--deviceName--$/$--deviceName--$.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\util; $--frameworkDirFromProjBs--$\include; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: $--bootloader--$; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_$--architectureId;U--$; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/$--deviceName--$/$--deviceName--$_endpoint_config.h"; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/$--deviceName--$/$--tokenHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/$--deviceName--$/$--deviceName--$.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--stackDirFromProjBs--$\app\framework\include; $--stackDirFromProjBs--$\app\util; $--stackDirFromProjBs--$\stack; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  postbuild: $--deviceName--$.bat $TARGET_BPATH$ \..\..\..
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: $--bootloader--$=1
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\micro\cortexm3\em35x\$--architectureId;L--$\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ./: call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    $--halDirFromProjFs--$/micro/cortexm3/: adc.c assert-crash-handlers.c button.c buzzer.c cstartup-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c token-def.c token.c uart.c ext-device.c spi-master.c
    $--frameworkDirFromProjFs--$/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c time-util.c util.c
    $--frameworkDirFromProjFs--$/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    $--frameworkDirProjFs--$/../util/serial/: command-interpreter2.c
    $--halDirFromProjFs--$/micro/generic/: crc.c endian.c mem-util.c random.c
    $--halDirFromProjFs--$/: ember-configuration.c
    $--frameworkDirProjFs--$/../util/common/: library.c
    $--frameworkDirFromProjFs--$/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    $--frameworkDirProjFs--$/../util/security/: security-address-cache.c
    $--halDirFromProjFs--$/plugin/serial/: serial.c
    $--halDirFromProjFs--$/micro/cortexm3/usb/: em_usbd.c em_usbtimer.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    $--halDirFromProjFs--$/micro/cortexm3/usb/cdc/: callbacks.c descriptors.c
    $--frameworkDirProjFs--$/../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
