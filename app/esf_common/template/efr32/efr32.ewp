# IAR project efr32.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: $--partNumber--$ SiliconLaboratories $--partNumber--$
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; PHY_EFR32; $--chipFamily;U--$; $--partNumber--$; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\rf4ce\include; $--frameworkDirFromProjBs--$\..\util; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\micro\cortexm3\efm32; $--halDirFromProjBs--$\micro\cortexm3\efm32\config; $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32; $--halDirFromProjBs--$\..\..\CMSIS\Include; $--halDirFromProjBs--$\..\..\Device\SiliconLabs\$--chipFamily--$\Include; $--halDirFromProjBs--$\..\..\emdrv\common\inc; $--halDirFromProjBs--$\..\..\emdrv\config; $--halDirFromProjBs--$\..\..\emdrv\dmadrv\inc; $--halDirFromProjBs--$\..\..\emdrv\ecode; $--halDirFromProjBs--$\..\..\emdrv\gpiointerrupt\inc; $--halDirFromProjBs--$\..\..\emdrv\rtcdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\sleep\inc; $--halDirFromProjBs--$\..\..\emdrv\spidrv\inc; $--halDirFromProjBs--$\..\..\emdrv\tempdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\uartdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\ustimer\inc; $--halDirFromProjBs--$\..\..\emlib\inc; $--halDirFromProjBs--$\..\..\middleware\glib; $--halDirFromProjBs--$\..\..\middleware\glib\glib; $--halDirFromProjBs--$\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; $--halDirFromProjBs--$\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_EFR32; $--chipFamily;U--$; $--partNumber--$; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\rf4ce\include; $--frameworkDirFromProjBs--$\..\util; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\micro\cortexm3\efm32; $--halDirFromProjBs--$\micro\cortexm3\efm32\config; $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32; $--halDirFromProjBs--$\..\..\CMSIS\Include; $--halDirFromProjBs--$\..\..\Device\SiliconLabs\$--chipFamily--$\Include; $--halDirFromProjBs--$\..\..\emdrv\common\inc; $--halDirFromProjBs--$\..\..\emdrv\config; $--halDirFromProjBs--$\..\..\emdrv\dmadrv\inc; $--halDirFromProjBs--$\..\..\emdrv\ecode; $--halDirFromProjBs--$\..\..\emdrv\gpiointerrupt\inc; $--halDirFromProjBs--$\..\..\emdrv\rtcdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\rtcdrv\test; $--halDirFromProjBs--$\..\..\emdrv\sleep\inc; $--halDirFromProjBs--$\..\..\emdrv\spidrv\inc; $--halDirFromProjBs--$\..\..\emdrv\tempdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\uartdrv\inc; $--halDirFromProjBs--$\..\..\emdrv\ustimer\inc; $--halDirFromProjBs--$\..\..\emlib\inc; $--halDirFromProjBs--$\..\..\middleware\glib; $--halDirFromProjBs--$\..\..\middleware\glib\glib; $--halDirFromProjBs--$\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; $--halDirFromProjBs--$\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  prebuild: $--deviceName--$-prebuild.bat $PROJ_DIR$
  postbuild: $--deviceName--$-postbuild.bat $TARGET_BPATH$
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: $--bootloader--$=1
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group emdrv
    $--halDirFromProjBs--$/../../emdrv/dmadrv/src/: dmadrv.c
    $--halDirFromProjBs--$/../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
    $--halDirFromProjBs--$/../../emdrv/rtcdrv/src/: rtcdriver.c
    $--halDirFromProjBs--$/../../emdrv/sleep/src/: sleep.c
    $--halDirFromProjBs--$/../../emdrv/spidrv/src/: spidrv.c
    $--halDirFromProjBs--$/../../emdrv/tempdrv/src/: tempdrv.c
    $--halDirFromProjBs--$/../../emdrv/uartdrv/src/: uartdrv.c
    $--halDirFromProjBs--$/../../emdrv/ustimer/src/: ustimer.c
  group emlib
    $--halDirFromProjBs--$/../../emlib/src/: em_adc.c em_cmu.c em_emu.c em_gpio.c em_int.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    $--halDirFromProjBs--$/../../Device/SiliconLabs/$--chipFamily;U--$/Source/: system_$--chipFamily;L--$.c
