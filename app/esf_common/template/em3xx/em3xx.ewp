# IAR project em3xx.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: $--bootloader--$; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_$--architectureId;U--$; PHY_EM3XX; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\rf4ce\include; $--frameworkDirFromProjBs--$\..\util; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\..\..\CMSIS\Include; $--halDirFromProjBs--$\..\..\Device\SiliconLabs\$--chipFamily;L--$\Include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: $--bootloader--$; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_$--architectureId;U--$; PHY_EM3XX; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  prebuild: $--deviceName--$-prebuild.bat $PROJ_DIR$
  postbuild: $--deviceName--$-postbuild.bat $TARGET_BPATH$
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: $--bootloader--$=1
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\micro\cortexm3\em35x\$--architectureId;L--$\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
